# Keil uVision project ciu32f003.uvprojx, settings and files
target Led9100_ciu (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: CIU32F003F5Px HED
  pack: HED.CIU32F003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x00000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led9100ciu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CIU32F003
  c include: ..\Include;..\..\Drivers\CIU32F003_Lib\Include;..\..\Drivers\CMSIS\Core;..\..\Drivers\CMSIS\Device
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group User
    ../Source/: main.c app_tcp.c app_service.c
  group BSP
    ../Source/: common.c tim_bsp.c SysTick_bsp.c usart_bsp.c output_bsp.c
  group CIU32F003_Lib
    ../../Drivers/CIU32F003_Lib/Source/: ciu32f003_std.c ciu32f003_std_adc.c ciu32f003_std_comp.c ciu32f003_std_crc.c ciu32f003_std_exti.c ciu32f003_std_flash.c ciu32f003_std_gpio.c ciu32f003_std_i2c.c ciu32f003_std_lptim.c ciu32f003_std_pmu.c ciu32f003_std_rcc.c ciu32f003_std_spi.c ciu32f003_std_tim.c ciu32f003_std_uart.c
  group CMSIS
    ../../Drivers/CMSIS/Device/: system_ciu32f003.c
  group Startup
    ./: startup_ciu32f003.s
  group Doc
    ../: readme.txt
